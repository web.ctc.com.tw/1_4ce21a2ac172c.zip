Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
File name: Project Number
Time: 2010-11-16T13:12:58
Written by: Autodesk Revit Structure 2011 - 1.0
Made in: 20100903_2115

# IfcProject, Project Number
Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2
PSet_Revit_Other - Project Issue Date: Issue Date; Project Status: Project Status; Client Name: Owner; Project Address: Enter address here; Project Name: Project Name; Project Number: Project Number

# IfcBuildingStorey (2)
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Line Pattern: Center; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm
Name | Elevation (mm) = PSet_Revit_Constraints, Elevation (mm) | Name
Level 1 | 0 | Level 1
Level 2 | 3000 | Level 2

# IfcColumn: 600 x 750mm (2)
Type - ElementType: 600 x 750mm; PredefinedType: COLUMN
Material: Concrete - Cast-in-Place Concrete
BaseQuantities - Length: 3000 mm; CrossSectionArea: 450000 mm2; OuterSurfaceArea: 9000000 mm2; GrossVolume: 1350000000 mm3
Pset_ColumnCommon - Reference: M_Concrete-Rectangular-Column:600 x 750mm; IsExternal: no; LoadBearing: yes; Slope: 0 deg
PSet_Revit_Materials and Finishes - Column Material: Concrete - Cast-in-Place Concrete
PSet_Revit_Constraints - Base Offset: 0 mm; Top Level: Level 2; Column Style: 0; Moves With Grids: yes; Room Bounding: yes
PSet_Revit_Structural Analysis - Top Release: 0; Top Fx: no; Top Fy: no; Top Fz: no; Top Mx: no; Top My: no; Top Mz: no; Bottom Release: 0; Bottom Fx: no; Bottom Fy: no; Bottom Fz: no; Bottom Mx: no; Bottom My: no; Bottom Mz: no; Analyze As: 1
PSet_Revit_Analytical Model - Rigid Links: no
PSet_Revit_Dimensions - Volume: 1350000000 mm3
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Structural - Rebar Cover - Top Face: Interior (framing, columns) <40>; Rebar Cover - Bottom Face: Interior (framing, columns) <40>; Rebar Cover - Other Faces: Interior (framing, columns) <40>
PSet_Revit_Type_Dimensions - b: 600 mm; h: 750 mm
PSet_Revit_Type_Identity Data - Cost: 7654321; OmniClass Number: 23.25.30.11.14.11; OmniClass Title: Columns
Name (M_Concrete-Rectangular-Column:600 x 750mm:600 x 750mm:...) | In | Base Level | Top Offset (mm) | Estimated Reinforcement Volume
152471 | Level 1 | Level 1 | 0 | 1.18423
152856 | Level 2 | Level 2 | 3000 | 1.10908

# IfcReinforcingMesh: Rebar Bar:32M (2)
MeshLength: 9.84252 mm; MeshWidth: 0.105971 mm; LongitudinalBarNominalDiameter: 0.105971 mm; TransverseBarNominalDiameter: 0.105971 mm; LongitudinalBarCrossSectionArea: 0.00881993 mm2; TransverseBarCrossSectionArea: 0.00881993 mm2; LongitudinalBarSpacing: 0.518027 mm; TransverseBarSpacing: 0.518027 mm
PSet_Revit_Construction - Schedule Mark: 1; Style: 0; Shape: Rebar Shape 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Rebar Set - Spacing: 157.895 mm; Quantity: 20; Layout Rule: 1
PSet_Revit_Type_Identity Data - Cost: 54321
PSet_Revit_Type_Dimensions - Bar Diameter: 32.3 mm; Standard Bend Diameter: 275 mm; Standard Hook Bend Diameter: 275 mm; Stirrup/Tie Bend Diameter: 275 mm; Maximum Bend Radius: 18000 mm
PSet_Revit_Type_Materials and Finishes - Material: Rebar - ASTM A615M - Grade 420 - Billet Steel
Name (Rebar Bar:32M:32M : Shape Rebar Shape 1:...) | In | Bar Length (mm) | Total Bar Length (mm) | A (mm) | B (mm) | C (mm) | D (mm) | Estimated Reinforcement Volume
152487 | Level 1 | 2046.25 | 40924.9 | 440.987 | 670 | 520 | 710 | 1.18423
152858 | Level 2 | 1916.39 | 38327.7 | 416.15 | 661.339 | 432.3 | 701.339 | 1.10908
